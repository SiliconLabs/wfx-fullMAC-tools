<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\WF200_driver_F429ZI_FreeRTOS.ewp</path>
  </project>
  <batchBuild/>
</workspace>


