# IAR project WF200_driver_F429ZI_FreeRTOS.ewp, settings and files
configuration WF200_driver_F429ZI_FreeRTOS-LwIP_SPI (ARM)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; SL_WFX_PROD_KEY; SL_WFX_USE_SPI
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\wfx_fmac_driver; ..\..\..\Drivers\wfx_fmac_driver\firmware\3.3.1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: WF200_driver_F429ZI_FreeRTOS_SPI.bin
  ILINK.IlinkOutputFile: WF200_driver_F429ZI_FreeRTOS.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration WF200_driver_F429ZI_FreeRTOS-LwIP_SDIO (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; SL_WFX_USE_SDIO; SL_WFX_SDIO_BLOCK_SIZE=64; SL_WFX_SDIO_BLOCK_MODE_THRESHOLD=512
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: WF200_driver_F429ZI_FreeRTOS_SDIO.bin
configuration WF200_driver_F429ZI_FreeRTOS-LwIP_SPI_Powersave (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; SL_WFX_PROD_KEY; SL_WFX_USE_SPI; SLEEP_ENABLED
  OBJCOPY.OOCOutputFile: WF200_driver_F429ZI_FreeRTOS_SPI_Powersave.bin
configuration WF200_driver_F429ZI_FreeRTOS-LwIP_SDIO_Powersave (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; SL_WFX_USE_SDIO; SL_WFX_SDIO_BLOCK_SIZE=64; SL_WFX_SDIO_BLOCK_MODE_THRESHOLD=512; SLEEP_ENABLED
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: WF200_driver_F429ZI_FreeRTOS_SDIO_Powersave.bin
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/SL_WFX_Host
    ../Src/sl_wfx_host/: sl_wfx_host.c sl_wfx_host_events.c sl_wfx_host_sdio.c sl_wfx_host_spi.c sl_wfx_task.c
  group Application/User
    ../Inc/: demo_config.h
    ../Src/: dhcp_client.c dhcp_server.c ethernetif.c freertos.c lwip_freertos.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c wifi_cli.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SL_WFX_Driver
    ../../../Drivers/wfx_fmac_driver/: sl_wfx.c
    ../../../Drivers/wfx_fmac_driver/bus/: sl_wfx_bus.c sl_wfx_bus_sdio.c sl_wfx_bus_spi.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LwIP/api
    ../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/apps
    ../../../Middlewares/Third_Party/LwIP/src/apps/lwiperf/: lwiperf.c
  group Middlewares/LwIP/apps/httpd
    ../../../Middlewares/Third_Party/LwIP/src/apps/http/: fs.c httpd.c
  group Middlewares/LwIP/core
    ../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/core/IPv4
    ../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/netif
    ../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
