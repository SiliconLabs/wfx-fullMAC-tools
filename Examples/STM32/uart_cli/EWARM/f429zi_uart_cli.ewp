# IAR project f429zi_uart_cli.ewp, settings and files
configuration spi (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; SL_WFX_USE_SPI; SL_WFX_PROD_KEY; FREERTOS; SL_WFX_CLI_PARAM_NB_MAX_PARAMS=25
  ICCARM.CCIncludePath2: ..\Inc; ..\..\shared\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\shared\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\shared\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\shared\Middlewares\Third_Party\FreeRTOS_CLI; ..\..\shared\Middlewares\Third_Party\LwIP\src\include; ..\..\shared\Middlewares\Third_Party\LwIP\system; ..\..\shared\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\shared\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\shared\Drivers\CMSIS\Include; ..\..\..\..\wfx-fullMAC-driver\wfx_fmac_driver; ..\..\..\..\wfx-fullMAC-driver\wfx_fmac_driver\firmware; ..\..\..\..\PDS; ..\..\..\..\Tools\sl_wfx_common_cli; ..\..\..\..\Tools\sl_wfx_common_cli\sl_wfx_cli_generic; ..\..\..\..\Tools\sl_wfx_common_cli\sl_wfx_rf_test_agent; ..\..\..\..\Tools\iPerf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: f429zi_uart_cli_spi.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sdio (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; SL_WFX_USE_SDIO; SL_WFX_SDIO_BLOCK_SIZE=64; SL_WFX_SDIO_BLOCK_MODE_THRESHOLD=512; SL_WFX_PROD_KEY; FREERTOS; SL_WFX_CLI_PARAM_NB_MAX_PARAMS=25
  OBJCOPY.OOCOutputFile: f429zi_uart_cli_sdio.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$_sdio.out
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/SL_WFX_Common_CLI
    ../../../../Tools/sl_wfx_common_cli/sl_wfx_cli_generic/: sl_wfx_cli_generic.c sl_wfx_cli_generic_freertos.c
    ../../../../Tools/sl_wfx_common_cli/: sl_wfx_cli_ip.c sl_wfx_cli_param.c sl_wfx_cli_rf_test_agent.c sl_wfx_cli_secure_link.c sl_wfx_cli_wifi.c
    ../../../../Tools/sl_wfx_common_cli/sl_wfx_rf_test_agent/: sl_wfx_rf_test_agent.c
  group Application/SL_WFX_Host
    ../Src/sl_wfx_host/: sl_wfx_host.c sl_wfx_host_events.c sl_wfx_host_sdio.c sl_wfx_host_spi.c sl_wfx_task.c
  group Application/User
    ../Src/: dhcp_client.c dhcp_server.c ethernetif.c freertos.c lwip_freertos.c lwip_param.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c
    ../../../../Tools/iPerf/: lwiperf.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/SL_WFX_Driver
    ../../../../wfx-fullMAC-driver/wfx_fmac_driver/: sl_wfx.c
    ../../../../wfx-fullMAC-driver/wfx_fmac_driver/bus/: sl_wfx_bus.c sl_wfx_bus_sdio.c sl_wfx_bus_spi.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../shared/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FreeRTOS
    ../../shared/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../shared/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../shared/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../shared/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/FreeRTOS_CLI
    ../../shared/Middlewares/Third_Party/FreeRTOS_CLI/: FreeRTOS_CLI.c
  group Middlewares/LwIP/api
    ../../shared/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/core
    ../../shared/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/core/IPv4
    ../../shared/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/netif
    ../../shared/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../../shared/Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
