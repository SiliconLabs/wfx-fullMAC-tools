<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\f429zi_uart_cli.ewp</path>
  </project>
  <batchBuild/>
</workspace>


