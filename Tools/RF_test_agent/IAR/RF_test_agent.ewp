# IAR project RF_test_agent.ewp, settings and files
configuration RF_test_agent_SLSTK3701A_SPI - Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFM32GG11B820F2048GL192; DEBUG_EFM; RETARGET_VCOM; SL_WFX_USE_SPI
  ICCARM.CCIncludePath2: ..\..\..\Examples\SiliconLabs\sdk\platform\CMSIS\Include; ..\..\..\Examples\SiliconLabs\sdk\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\Examples\SiliconLabs\sdk\platform\emlib\inc; ..\..\..\Examples\SiliconLabs\sdk\platform\emdrv\common\inc; ..\..\..\Examples\SiliconLabs\sdk\platform\emdrv\spidrv\inc; ..\..\..\Examples\SiliconLabs\sdk\platform\emdrv\spidrv\config; ..\..\..\Examples\SiliconLabs\sdk\platform\emdrv\dmadrv\inc; ..\..\..\Examples\SiliconLabs\sdk\platform\emdrv\dmadrv\config; ..\..\..\Examples\SiliconLabs\sdk\platform\emdrv\rtcdrv\inc; ..\..\..\Examples\SiliconLabs\sdk\platform\emdrv\rtcdrv\config; ..\..\..\Examples\SiliconLabs\sdk\hardware\kit\common\bsp; ..\..\..\Examples\SiliconLabs\sdk\hardware\kit\common\drivers; ..\..\..\Examples\SiliconLabs\sdk\hardware\kit\SLSTK3701A_EFM32GG11\config; ..; ..\inc; ..\Drivers\wfx_fmac_driver\; ..\Drivers\wfx_fmac_driver\bus; ..\Drivers\wfx_fmac_driver\firmware; ..\Drivers\wfx_fmac_driver\firmware\3.0.0; ..\Drivers\wfx_fmac_driver\sl; ..\targets\slstk3701a\wfx_host
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: RF_test_agent_SLSTK3701A_SPI.bin
  ILINK.IlinkOutputFile: RF_test_agent_SLSTK3701A_SPI.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RF_test_agent_NUCLEOF429_SPI - Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; SL_WFX_USE_SPI
  ICCARM.CCIncludePath2: ..; ..\inc; ..\..\..\Examples\STM32\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\wfx_fmac_driver\; ..\Drivers\wfx_fmac_driver\bus; ..\Drivers\wfx_fmac_driver\firmware; ..\Drivers\wfx_fmac_driver\firmware\3.0.0; ..\Drivers\wfx_fmac_driver\sl; ..\targets\nucleo-f429; ..\..\..\Examples\STM32\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Examples\STM32\Drivers\CMSIS\Include; ..\targets\nucleo-f429\sl_wfx_host
  AARM.ADefines: STM32F429xx; USE_HAL_DRIVER; SL_WFX_USE_SPI
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: RF_test_agent_NUCLEOF429_SPI.bin
  ILINK.IlinkOutputFile: RF_test_agent_NUCLEOF429_SPI.out
configuration RF_test_agent_SLSTK3701A_SPI - Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration RF_test_agent_NUCLEOF429_SPI - Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; SL_WFX_USE_SPI; NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: STM32F429xx; USE_HAL_DRIVER; SL_WFX_USE_SPI; NDEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: RF_test_agent_NUCLEOF429_SPI.bin
  ILINK.IlinkOutputFile: RF_test_agent_NUCLEOF429_SPI.out
configuration RF_test_agent_NUCLEOF429_SDIO - Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; SL_WFX_PROD_KEY; SL_WFX_USE_SDIO; SL_WFX_SDIO_BLOCK_MODE_THRESHOLD=512; SL_WFX_SDIO_BLOCK_SIZE=64
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: RF_test_agent_NUCLEOF429_SDIO.bin
  ILINK.IlinkOutputFile: RF_test_agent_NUCLEOF429_SDIO.out
configuration RF_test_agent_NUCLEOF429_SDIO - Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; NDEBUG; SL_WFX_PROD_KEY; SL_WFX_USE_SDIO; SL_WFX_SDIO_BLOCK_MODE_THRESHOLD=512; SL_WFX_SDIO_BLOCK_SIZE=64
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: RF_test_agent_NUCLEOF429_SDIO.bin
  ILINK.IlinkOutputFile: RF_test_agent_NUCLEOF429_SDIO.out
  group Application
    ../src/: main.c sl_wfx_test_agent.c
  group Drivers
    ../../../Examples/SiliconLabs/sdk/hardware/kit/common/drivers/: retargetio.c retargetserial.c udelay.c
  group Drivers/dmadrv
    ../../../Examples/SiliconLabs/sdk/platform/emdrv/dmadrv/src/: dmadrv.c
  group Drivers/emlib
    ../../../Examples/SiliconLabs/sdk/platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_usart.c
  group Drivers/rtcdrv
    ../../../Examples/SiliconLabs/sdk/platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers/spidrv
    ../../../Examples/SiliconLabs/sdk/platform/emdrv/spidrv/src/: spidrv.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Examples/STM32/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_sdmmc.c
  group Drivers/wfx_fmac_driver
    ../Drivers/wfx_fmac_driver/: sl_wfx.c
    ../Drivers/wfx_fmac_driver/bus/: sl_wfx_bus.c sl_wfx_bus_sdio.c sl_wfx_bus_spi.c
  group Targets/nucleo-f429
    ../targets/nucleo-f429/: host_resources.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Targets/nucleo-f429/CMSIS
    ../../../Examples/STM32/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
    ../../../Examples/STM32/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Targets/nucleo-f429/wfx_host
    ../targets/nucleo-f429/sl_wfx_host/: sl_wfx_host.c sl_wfx_host_sdio.c sl_wfx_host_spi.c
  group Targets/slstk3701a
    ../../../Examples/SiliconLabs/sdk/hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../targets/slstk3701a/: host_resources.c
  group Targets/slstk3701a/CMSIS
    ../../../Examples/SiliconLabs/sdk/platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../Examples/SiliconLabs/sdk/platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group Targets/slstk3701a/wfx_host
    ../targets/slstk3701a/wfx_host/: wfx_host.c wfx_host_cfg.h wfx_host_spi.c
